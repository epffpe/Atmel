# IAR project Start_ATMega64.ewp, settings and files
configuration Debug (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x64
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: OS_LIBMODE_DP
  ICCAVR.newCCIncludePaths: ..\..\..\Inc\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm64.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: OS_LIBMODE_R
configuration CSpy_Simulator (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: OS_LIBMODE_D; OS_UART=-1
  group (top)
    ./: Readme.txt
  group Application
    Application/: Start_2Tasks.c
  group Application/Excluded
    Application/: ExtendTaskContext.c Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_LEDBlink.c
  group Lib
    ../../../Lib/: Rtos3SSF_D.r90 Rtos3SSF_DP.r90 Rtos3SSF_DT.r90 Rtos3SSF_R.r90 Rtos3SSF_S.r90 Rtos3SSF_SP.r90 Rtos3SSF_XR.r90
  group Setup
    Setup/: BSP.c CSpy_ATmega64.mac OS_Error.c Rtosinit_ATmega64.c
