# IAR project Start_ATMega103.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x64
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: DEBUG=1
  ICCAVR.newCCIncludePaths: ..\..\..\Inc\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm103.xcl
configuration Release (AVR)
  as the first configuration, except:
configuration CSpy_Simulator (AVR)
  as the first configuration, except:
  group (top)
    ./: Readme.txt
  group Application
    Application/: Start_2Tasks.c
  group Application/Excluded
    Application/: ExtendTaskContext.c Main_EVENT.c Main_OS_Q.c Main_TaskEx.c MeasureCST_HRTimer_embOSView.c MeasureCST_HRTimer_Printf.c MeasureCST_Scope.c PerformanceTest.c Start_LEDBlink.c
  group Lib
    ../../../Lib/: Rtos3S_DP.r90 Rtos3S_R.r90
  group Setup
    Setup/: BSP.c CSpy_ATmega103.mac lnk3s4kb.xcl OS_Error.c Rtosinit_ATmega103.c
